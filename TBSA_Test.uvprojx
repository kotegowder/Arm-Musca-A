# Keil uVision project TBSA_Test.uvprojx, settings and files
target TBSA_Test (6090000::V6.9::.\ARMCLANG)
  device: Musca:Cortex-M33-0 ARM
  pack: ARM.Musca_A1_BSP.1.0.2
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10200000,0x00040000) IROM2(0x00200000,0x00040000) CPUTYPE("Cortex-M33") TZ CLOCK(12000000) ESEL ELITTLE
  output: TBSA_Test
  BeforeMake: fromelf --bin "C:\cygwin\home\vinkot01\projects\tbsa_internal\syscomp_tbsa_m\out\musca_a\tbsa.elf" --output ".\TBSA_Objects"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __USE_FLASH ARM_MATH_ARMV8MML
  c misc: -mcmse -D__DOMAIN_NS=0
  c include: .\common
  memory RVCT4: ROM 0x10200000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\musca_a.sct
  link misc: --predefine="-D__USE_FLASH"
  group User
    ./: main.c s_get_serial.c
    ./common/: serial.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Native Driver:Native UART 1.0.0
